## drivers/huawei/boottime/Kconfig
```kconfig
config HUAWEI_BOOT_TIME
       default y
	   bool "huawei boot time"
       help
			set beta or commercial version to kernel.
```
